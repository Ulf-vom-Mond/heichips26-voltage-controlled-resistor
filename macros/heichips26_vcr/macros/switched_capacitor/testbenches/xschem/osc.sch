v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {sg13cmos5l_stdcells/sg13cmos5l_dlygate4sd1_1.sym} 0 -30 0 0 {name=x1 VDD=VDD VSS=VSS prefix=sg13cmos5l_ }
C {sg13cmos5l_pr/gallery.sym} 0 -100 0 0 {name=x2}
C {sg13cmos5l_stdcells/IHP130_stdcells.sym} -130 70 0 0 {name=x3}
